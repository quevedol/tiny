VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;
UNITS
   DATABASE MICRONS 1000 ;
END UNITS

MACRO qvic_logo
   CLASS BLOCK ;
   FOREIGN qvic_logo 0 0 ;
   SIZE 32.000 BY 14.500 ;
   SYMMETRY X Y ;
   OBS
      LAYER met4 ;
         RECT 0.000 0.000 32.000 14.500 ;
   END
END qvic_logo

END LIBRARY
